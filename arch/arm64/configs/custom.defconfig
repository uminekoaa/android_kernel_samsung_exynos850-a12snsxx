## arch/arm64/configs/custom.defconfig
```kconfig
# disable kprobes
CONFIG_KPROBES=n
CONFIG_HAVE_KPROBES=n
CONFIG_KPROBE_EVENTS=n

# enable KSU
CONFIG_KSU=y
CONFIG_KSU_MANUAL_HOOK=y
```
